DESCRIPTION = "FrostEyes base image"

require recipes-core/images/core-image-minimal.bb

#IMAGE_INSTALL += "dummy-app"
